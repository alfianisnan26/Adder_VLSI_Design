CIRCUIT E:\Tugas\Semester_6\PVL\adder\adder.MSK
*
* IC Technology: CMOS 90nm, 6 Metal Copper - strained SiGe - LowK
*
VDD 1 0 DC 1.20
VCin 18 0 DC 0 PULSE(0.00 1.20 0.79N 0.01N 0.01N 0.79N 1.60N)
VB 20 0 DC 0 PULSE(0.00 1.20 0.39N 0.01N 0.01N 0.39N 0.80N)
VA 21 0 DC 0 PULSE(0.00 1.20 0.19N 0.01N 0.01N 0.19N 0.40N)
*
* List of nodes
* " and2_5_w9" corresponds to n°3
* "N5" corresponds to n°5
* " or2_4_Cout" corresponds to n°6
* "N7" corresponds to n°7
* "N8" corresponds to n°8
* " xor2_3_S" corresponds to n°9
* " and2_2_w7" corresponds to n°12
* " xor2_1_w5" corresponds to n°14
* "Cin" corresponds to n°18
* "B" corresponds to n°20
* "A" corresponds to n°21
*
* MOS devices
MN1 0 5 3 0 N1  W= 0.20U L= 0.10U
MN2 17 18 5 0 N1  W= 0.20U L= 0.10U
MN3 0 14 17 0 N1  W= 0.20U L= 0.10U
MN4 0 7 6 0 N1  W= 0.20U L= 0.10U
MN5 7 12 0 0 N1  W= 0.20U L= 0.10U
MN6 0 3 7 0 N1  W= 0.20U L= 0.10U
MN7 0 10 9 0 N1  W= 0.20U L= 0.10U
MN8 18 14 10 0 N1  W= 0.20U L= 0.10U
MN9 0 18 11 0 N1  W= 0.20U L= 0.10U
MN10 0 13 12 0 N1  W= 0.20U L= 0.10U
MN11 19 20 13 0 N1  W= 0.20U L= 0.10U
MN12 0 21 19 0 N1  W= 0.20U L= 0.10U
MN13 0 15 14 0 N1  W= 0.20U L= 0.10U
MN14 20 21 15 0 N1  W= 0.20U L= 0.10U
MN15 0 20 16 0 N1  W= 0.20U L= 0.10U
MP1 1 5 3 1 P1  W= 0.50U L= 0.10U
MP2 5 18 1 1 P1  W= 0.50U L= 0.10U
MP3 1 14 5 1 P1  W= 0.50U L= 0.10U
MP4 1 7 6 1 P1  W= 0.50U L= 0.10U
MP5 8 12 7 1 P1  W= 0.50U L= 0.10U
MP6 1 3 8 1 P1  W= 0.50U L= 0.10U
MP7 1 10 9 1 P1  W= 0.50U L= 0.10U
MP8 11 14 10 1 P1  W= 0.50U L= 0.10U
MP9 1 18 11 1 P1  W= 0.50U L= 0.10U
MP10 1 13 12 1 P1  W= 0.50U L= 0.10U
MP11 13 20 1 1 P1  W= 0.50U L= 0.10U
MP12 1 21 13 1 P1  W= 0.50U L= 0.10U
MP13 1 15 14 1 P1  W= 0.50U L= 0.10U
MP14 16 21 15 1 P1  W= 0.50U L= 0.10U
MP15 1 20 16 1 P1  W= 0.50U L= 0.10U
*
C2 1 0  9.212fF
C3 3 0  1.090fF
C5 5 0  0.552fF
C6 6 0  1.204fF
C7 7 0  0.563fF
C8 8 0  0.125fF
C9 9 0  1.072fF
C10 10 0  0.519fF
C11 11 0  0.478fF
C12 12 0  1.024fF
C13 13 0  0.552fF
C14 14 0  1.349fF
C15 15 0  0.519fF
C16 16 0  0.478fF
C17 17 0  0.071fF
C18 18 0  1.170fF
C19 19 0  0.071fF
C20 20 0  0.730fF
C21 21 0  0.562fF
*
*
* n-MOS BSIM4 :
* low leakage
.MODEL N1 NMOS LEVEL=14 VTHO=0.28 U0=0.060 TOXE= 1.2E-9 LINT=0.015U
+K1 =0.450 K2=0.100 DVT0=2.300
+DVT1=0.570 LPE0=23.000e-9 ETA0=0.080
+NFACTOR=  0.9 U0=0.060 UA=3.400e-15
+WINT=0.005U LPE0=23.000e-9
+KT1=-0.060 UTE=-1.800 VOFF=0.010
+XJ=0.150U NDEP=170.000e15 PCLM=1.100
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p
*
* p-MOS BSIM4:
* low leakage
.MODEL P1 PMOS LEVEL=14 VTHO=-0.32 U0=0.027 TOXE= 1.2E-9 LINT=0.015U
+K1 =0.450 K2=0.100 DVT0=2.300
+DVT1=0.570 LPE0=23.000e-9 ETA0=0.080
+NFACTOR=  1.9 U0=0.027 UA=2.200e-15
+WINT=0.005U LPE0=23.000e-9
+KT1=-0.060 UTE=-1.800 VOFF=0.010
+XJ=0.150U NDEP=170.000e15 PCLM=0.700
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p
*
* Transient analysis
*
* (Winspice)
.options temp=27.0
.control
tran 0.1N 5.00N
print  V(20) V(21) V(18) V(9) V(6) > out.txt
plot  V(20) V(21) V(18) V(9) V(6)
.endc
.END
